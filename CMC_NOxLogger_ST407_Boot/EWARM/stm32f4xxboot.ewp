# IAR project stm32f4xxboot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\App; ..\Config; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\Libraries\FAT_FS; ..\Libraries\FAT_FS\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f4xxboot.bin
  ILINK.IlinkOutputFile: stm32f4xxboot.out
  ILINK.IlinkIcfFile: ..\Config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: Bootstart.c bsp.c main.c sstflash.c
  group Config
    ../Config/: startup_stm32f4xx.s stm32f4xx_conf.h system_stm32f4xx.c
  group FAT_FS
    ../Libraries/FAT_FS/: diskio.c ff.c
  group FAT_FS/driver
    ../Libraries/FAT_FS/drivers/: fatfs_sd_sdio.c
  group FAT_FS/option
    ../Libraries/FAT_FS/option/: syscall.c unicode.c
  group StdPeriph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
