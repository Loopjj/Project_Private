# IAR project OBDPro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VE ST STM32F205VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; ..\cpu; ..\Drv; ..\App; ..\App\fat; ..\bsp; ..\Dev; ..\OsConfig; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\Libraries\FAT_FS\inc; ..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\Libraries\USB\STM32_USB_HOST_Library\Class\MSC\inc; ..\Libraries\USB\STM32_USB_HOST_Library\Core\inc; ..\Libraries\USB\STM32_USB_OTG_Driver\inc; ..\Util\Third_Party\FreeRTOS_v7.6.0\portable\IAR\ARM_CM3; ..\Util\Third_Party\FreeRTOS_v7.6.0\include; ..\OsConfig\usbConf; ..\Libraries\FAT_FS; ..\Libraries\FAT_FS\drivers
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\OsConfig
  OBJCOPY.OOCOutputFile: OBDPro.bin
  postbuild: Debug\Exe\crcgen_ccitt.exe Debug\Exe\OBDPro.bin 1405
  ILINK.IlinkOutputFile: OBDPro.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: avg.c can.c crc16.c debug.c delay.c drivefree.c extern.c extern.h fnd.c guiproto.c key.c modem.c modem_Loop.c modem_sms.c nmeap.c nv.c obd.c sys_struct.c usb_msc_app.c
    ../cpu/: includes.h
  group Bsp
    ../bsp/: bsp_free.c bsp_util.c usb_bsp.c usbh_usr.c
  group Cpu
    ../cpu/: main.c
  group Dev
    ../Dev/: fsmc_nand.c i2cfram_FM24CL64B.c spi_MAX6675.c spiflash_W25Q64BV.c
  group Drv
    ../Drv/: cli.c commrtos.c tmr.c
  group Libraries/CMSIS/CoreSupport
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Libraries/CMSIS/DeviceSupport/STM32F2xx
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Libraries/CMSIS/DeviceSupport/STM32F2xx/startup/IAR
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group Libraries/FAT_FS
    ../Libraries/FAT_FS/: diskio.c ff.c
  group Libraries/FAT_FS/drivers
    ../Libraries/FAT_FS/drivers/: fatfs_sd_sdio.c fatfs_usb.c
  group Libraries/FAT_FS/option
    ../Libraries/FAT_FS/option/: syscall.c unicode.c
  group Libraries/STM32F2xx_Stdperiph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_cryp.c stm32f2xx_cryp_tdes.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group Libraries/USB/STM32_USB_HOST_Library/Class/MSC
    ../Libraries/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group Libraries/USB/STM32_USB_HOST_Library/Core
    ../Libraries/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group Libraries/USB/STM32F_USB_OTG_Driver
    ../Libraries/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group OsConfig
    ../OsConfig/: stm32f2xx_it.c
  group Util/FreeRTOS_V760
    ../Util/Third_Party/FreeRTOS_v7.6.0/: croutine.c list.c queue.c Rtimers.c tasks.c
  group Util/FreeRTOS_V760/prtable/IAR/ARM_CM3
    ../Util/Third_Party/FreeRTOS_v7.6.0/portable/IAR/ARM_CM3/: port.c portasm.s
  group Util/FreeRTOS_V760/prtable/MemMang
    ../Util/Third_Party/FreeRTOS_v7.6.0/portable/MemMang/: heap_2.c
