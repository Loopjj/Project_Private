# IAR project OBDPro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\App; ..\Bsp; ..\Cpu; ..\Drv; ..\Dev; ..\EWARM; ..\OsConfig; ..\user\inc; ..\STM32_Lib\CMSIS\ST\STM32F4xx\Include; ..\STM32_Lib\STM32F4xx_StdPeriph_Driver\inc; ..\Utilities\Third_Party\FreeRTOS_v9.0.0\include; ..\Utilities\Third_Party\FreeRTOS_v9.0.0\portable\IAR\ARM_CM4F; ..\STM32_Lib\FAT_FS; ..\STM32_Lib\FAT_FS\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\OsConfig; ..\STM32_Lib\CMSIS\ST\STM32F4xx\Include
  OBJCOPY.OOCOutputFile: OBDPro.bin
  postbuild: Debug\Exe\crcgen_ccitt.exe Debug\Exe\OBDPro.bin 1405
  ILINK.IlinkOutputFile: OBDPro.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: avg.c can.c crc16.c debug.c delay.c drivefree.c extern.c fnd.c guiproto.c key.c modem.c modem_Loop.c modem_sms.c nmeap01.c nv.c obd.c sys_struct.c
  group Bsp
    ../Bsp/: bsp.h bsp_free.c bsp_util.c
  group Cpu
    ../Cpu/: includes.h main.c
  group Dev
    ../Dev/: i2cfram_FM24CL64B.c spi_MAX6675.c spiflash_W25Q64BV.c
  group Drv
    ../Drv/: cli.c commrtos.c tmr.c
  group EWARM
    ../EWARM/: startup_stm32f4xx.s
  group STM32F4xx/FAT_FS
    ../STM32_Lib/FAT_FS/: diskio.c ff.c
  group STM32F4xx/FAT_FS/drivers
    ../STM32_Lib/FAT_FS/drivers/: fatfs_sd_sdio.c
  group STM32F4xx/FAT_FS/option
    ../STM32_Lib/FAT_FS/option/: syscall.c unicode.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../STM32_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../OsConfig/: FreeRTOSConfig.h
    ../User/src/: stm32f4xx_it.c system_stm32f4xx.c
  group Util/FreeRTOS_V900
    ../Utilities/Third_Party/FreeRTOS_v9.0.0/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Util/FreeRTOS_V900/porable/IAR/ARM_CM4F
    ../Utilities/Third_Party/FreeRTOS_v9.0.0/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Util/FreeRTOS_V900/porable/MemMang
    ../Utilities/Third_Party/FreeRTOS_v9.0.0/portable/MemMang/: heap_2.c
