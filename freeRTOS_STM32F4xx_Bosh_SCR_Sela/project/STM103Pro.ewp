# IAR project STM103Pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\App; ..\Bsp; ..\Cpu; ..\Drv; ..\Dev; ..\EWARM; ..\OsConfig; ..\user\inc; ..\STM32_Lib\CMSIS\ST\STM32F4xx\Include; ..\STM32_Lib\STM32F4xx_StdPeriph_Driver\inc; ..\Utilities\Third_Party\FreeRTOS_v7.6.0\include; ..\Utilities\Third_Party\FreeRTOS_v7.6.0\portable\IAR\ARM_CM4F; ..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7; ..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS; ..\Utilities\Third_Party\lwip-1.4.1\src\include; ..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4; ..\Utilities\Third_Party\FatFs_vR0.08a
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\OsConfig; ..\STM32_Lib\CMSIS\ST\STM32F4xx\Include
  OBJCOPY.OOCOutputFile: SCRPro.bin
  ILINK.IlinkOutputFile: STM103Pro.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: average.c crc16.c debug.c ecuprotocol.c guiprotocol.c nv.c obdprotocol.c pid.c scr.c scr.h sys_struct.c
    ../Cpu/: includes.h
  group Bsp
    ../Bsp/: bsp_free.c bsp_util.c
  group Cpu
    ../Cpu/: main.c
  group Dev
    ../Dev/: fsmc_nand.c i2cfram_FM24CL64B.c spiflash_W25Q64BV.c
  group Drv
    ../Drv/: cli.c commrtos.c ieee754.c tmr.c
  group EWARM
    ../EWARM/: startup_stm32f4xx.s
  group FatFs_Vr0.08a
    ../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group FreeRTOSv760
    ../Utilities/Third_Party/FreeRTOS_v7.6.0/: croutine.c list.c queue.c Rtimers.c tasks.c
  group FreeRTOSv760/portable/ARM_CM3
    ../Utilities/Third_Party/FreeRTOS_v7.6.0/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeRTOSv760/portable/ARM_CM4F
    ../Utilities/Third_Party/FreeRTOS_v7.6.0/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOSv760/portable/MemMang
    ../Utilities/Third_Party/FreeRTOS_v7.6.0/portable/MemMang/: heap_2.c heap_4.c
  group LwIP_V141/port/FreeRTOS
    ../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: sys_arch.c
  group LwIP_V141/src/api
    ../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_V141/src/core
    ../Utilities/Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_V141/src/core/ipv4
    ../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP_V141/src/core/snmp
    ../Utilities/Third_Party/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group LwIP_V141/src/netif
    ../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c slipif.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../STM32_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group user
    ../user/src/: fs.c stm32f4xx_it.c system_stm32f4xx.c
